<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>square_timing_recovery</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>category</key><value>Synchronizers</value></param>
<param><key>description</key><value>timing synchronization using square timing recovery</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>square timing recovery</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>scale</key><value>-1.0/(2*np.pi)*sps</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>nfft</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_1</value></param>
<param><key>freq</key><value>1</value></param>
<param><key>len</key><value>nfft</value></param>
<param><key>rate</key><value>sps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>index_selector</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class blk(gr.decim_block):
    def __init__(self, sps=8):  # only default arguments here
        gr.decim_block.__init__(
            self,
            name='Index Selector',
            in_sig=[np.complex64, np.int32],
            out_sig=[np.complex64],
            decim=sps
        )
        self.sps = sps
        self.set_history(self.sps/2+1)

    def work(self, input_items, output_items):
        num_symbols = len(output_items[0][:])/self.sps
        for i in range(num_symbols):
            output_items[0][i] = input_items[0][i*self.sps + input_items[1][i*self.sps] + self.sps/2]
        return num_symbols
</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nfft</value></param>
<param><key>label</key><value>nfft</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>goertzel decimates by nfft</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>dbg_spectrum</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>label</key><value>dbg_index</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>dbg_phase</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>samples per symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_float_to_int_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>pad_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>goertzel_fc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>index_selector</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>goertzel_fc_1</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>index_selector</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>index_selector</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
